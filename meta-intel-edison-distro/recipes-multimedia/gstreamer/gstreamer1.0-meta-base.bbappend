# Overlay the gstreamer meta base to embed more audio plugins

RDEPENDS_gstreamer1.0-meta-audio += " \
    gstreamer1.0-plugins-good-pulse \
    gstreamer1.0-plugins-base-audiotestsrc \
    "

