FILESEXTRAPATHS_prepend := "${THISDIR}/openssh"
