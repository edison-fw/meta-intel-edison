FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = "file://0001-shared-shell-Fix-init-script-commandline-option.patch"

