require u-boot-internal-devenv.inc

SRC_URI += "file://fw_env.config"
