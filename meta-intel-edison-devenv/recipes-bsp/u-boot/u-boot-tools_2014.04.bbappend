require u-boot-internal-devenv.inc

