FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-v8-fix-build-errors-with-g-7.patch"
