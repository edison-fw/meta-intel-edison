RDEPENDS_${PN}-tests =+ " bash"
