IMAGE_INSTALL += "clloader"

