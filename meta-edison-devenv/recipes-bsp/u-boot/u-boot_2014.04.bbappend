EXTERNALSRC_pn_u-boot = "${EDISONREPO_TOP_DIR}/u-boot"
INHERIT += "externalsrc"

require u-boot-internal-devenv.inc

