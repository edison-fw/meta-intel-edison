# Shortening a name due to 255 chars limitations
# See https://bugzilla.yoctoproject.org/show_bug.cgi?id=6957
PV = "0_9_33"
