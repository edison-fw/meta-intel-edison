SRC_URI = "http://mirrors.kernel.org/sourceware/pthreads-win32/pthreads-w32-${PVdash}-release.tar.gz"
